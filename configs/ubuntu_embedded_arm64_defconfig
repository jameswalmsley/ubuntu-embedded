## configs/ubuntu_embedded_arm64_defconfig
```kconfig
CONFIG_RECIPE:=ubuntu-embedded
CONFIG_VARIANT:=arm64
CONFIG_OVERLAYFS=y
CONFIG_OVERLAYFS_ROOTFS_PATH:=rootfs
```
